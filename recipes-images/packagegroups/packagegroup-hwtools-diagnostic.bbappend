RDEPENDS:${PN}:remove:phycontrol-nova-imx8mp-1 = "lmsensors-fancontrol"
