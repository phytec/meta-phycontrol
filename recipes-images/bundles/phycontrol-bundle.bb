require recipes-images/bundles/phytec-base-bundle.inc

RAUC_SLOT_rootfs ?= "phycontrol-image"
