FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-build-Create-missing-src-common-directory-in-build-t.patch \
"
